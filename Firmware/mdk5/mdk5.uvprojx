# Keil uVision project mdk5.uvprojx, settings and files
target mdk (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mdk5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\test\core;..\test\system;..\test\libraries\inc;..\test\gd32f10x_usbd;..\test\gd32f10x_usbd\GD32F10x_usbd_driver\Include;..\test\src\main;..\test\src\ina226;..\test\src\gd25q64e;..\test\src\st7789v3;..\test\src\lvgl8.2.0;..\test\src\lvgl8.2.0\lvgl;..\test\src\lvgl8.2.0\lvgl\src;..\test\src\lvgl8.2.0\lvgl\porting;..\test\src\UIKit;..\test\src\UIKit\LocalRPC;..\test\src\UIPages;..\test\src\UIPages\Resource\Symbol;..\test\src\UIPages\HAL;..\test\src\UIPages\Dialplate;..\test\src\UIPages\Info;..\test\src\UIPages\Recent;..\test\src\UIPages;..\test\src\qflow;..\test\src\blight;..\test\src\Utils
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../test/src/main/: key.c led.c main.c temp.c usart.c usbd_cdc.c
    ../test/src/gd25q64e/: gd25q64.c gd25q64_spi.c
    ../test/src/ina226/: ina226.c ina226_i2c.c kalman.c
    ../test/src/st7789v3/: st7789.c
    ../test/src/qflow/: qflow.c
    ../test/src/blight/: blight.c
  group core
    ../test/core/: startup_gd32f10x_hd.s core_cm3.h core_cmFunc.h core_cmInstr.h
  group system
    ../test/system/: system_gd32f10x.c gd32f10x.h gd32f10x_libopt.h system_gd32f10x.h
  group libraries
    ../test/libraries/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group usb_driver
    ../test/gd32f10x_usbd/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group usb_custom
    ../test/gd32f10x_usbd/: cdc_acm_core.c gd32f10x_it.c
  group lvgl_porting
    ../test/src/lvgl8.2.0/lvgl/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl_src
    ../test/src/lvgl8.2.0/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../test/src/lvgl8.2.0/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../test/src/lvgl8.2.0/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/led/: lv_led.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/list/: lv_list.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/span/: lv_span.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/widgets/win/: lv_win.c
    ../test/src/lvgl8.2.0/lvgl/src/extra/: lv_extra.c
    ../test/src/lvgl8.2.0/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../test/src/lvgl8.2.0/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../test/src/lvgl8.2.0/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../test/src/lvgl8.2.0/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group UIKit
    ../test/src/UIKit/: nt_action.c nt_pm.c nt_qq.c nt_shot.c
    ../test/src/UIKit/LocalRPC/: nt_account.c nt_master.c nt_ppbuf.c
  group UIView
    ../test/src/UIPages/Dialplate/: dialplate.c dialplateview.c
    ../test/src/UIPages/Info/: infos.c infosview.c
    ../test/src/UIPages/Recent/: recent.c recentview.c
  group Resource
    ../test/src/UIPages/Resource/Font/: font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_56.c font_bahnschrift_65.c font_celsius_24.c
    ../test/src/UIPages/Resource/Symbol/: symbol_chip_20.c
  group Utils
    ../test/src/Utils/: strifica.c time.c log.c nt_minitask.c
