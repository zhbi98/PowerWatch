# Keil uVision project PWatch_APP.uvprojx, settings and files
target PWatch_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mdk5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\lvgl8.2.0;..\lvgl8.2.0\lvgl;..\lvgl8.2.0\lvgl\src;..\lvgl8.2.0\lvgl\porting;..\UIKit;..\UIKit\LocalRPC;..\UIPages;..\UIPages\Resource\;..\UIPages\Resource\Symbol;..\UIPages\HAL;..\UIPages\Dialplate;..\UIPages\Info;..\UIPages\Recent;..\UIPages;..\device\gd25q64e;..\device\ina226;..\device\st7789v3;..\device\blight;..\drivers\CMSIS;..\drivers\CMSIS\GD\GD32F10x\Include;..\drivers\GD32F10x_standard_peripheral\Include;..\drivers\GD32F10x_usbd_driver;..\drivers\GD32F10x_usbd_driver\Include;..\main;..\hal\inc;..\Utils;..\blight;..\qflow
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../main/: usbd_cdc.c main.c
  group device
    ../device/blight/: blight.c
    ../device/gd25q64e/: gd25q64.c gd25q64_spi.c
    ../device/ina226/: ina226.c ina226_i2c.c kalman.c
    ../device/st7789v3/: st7789.c
    ../qflow/: qflow.c
  group Drivers
    ../drivers/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
    ../drivers/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../drivers/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
    ../drivers/GD32F10x_usbd_driver/: cdc_acm_core.c
    ../drivers/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group hal
    ../hal/src/: gd32f10x_it.c usart.c temp.c key.c led.c
  group lvgl_porting
    ../lvgl8.2.0/lvgl/porting/: lv_port_indev.c lv_port_disp.c
  group lvgl_src
    ../lvgl8.2.0/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl8.2.0/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../lvgl8.2.0/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl8.2.0/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl8.2.0/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl8.2.0/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl8.2.0/lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl8.2.0/lvgl/src/extra/: lv_extra.c
    ../lvgl8.2.0/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl8.2.0/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl8.2.0/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl8.2.0/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group UIKit
    ../UIKit/: nt_action.c nt_anim.c nt_pm.c nt_qq.c nt_rm.c
    ../UIKit/LocalRPC/: nt_account.c nt_master.c nt_ppbuf.c
  group UIView
    ../UIPages/Dialplate/: dialplate.c dialplateview.c
    ../UIPages/Info/: infos.c infosview.c
    ../UIPages/Recent/: recent.c recentview.c
  group Resource
    ../UIPages/Resource/Font/: font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_56.c
    ../UIPages/Resource/: resource.c
  group Utils
    ../Utils/: nt_minitask.c nt_shot.c strifica.c time.c
software components: Device:GD32F10x_libopt 2.2.4
