# Keil uVision project mdk5.uvprojx, settings and files
target mdk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mdk5 +hex
  AfterMake: fromelf.exe --bin -o .\mdk5.bin .\Objects\mdk5.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1295
  c include: ..\test\src;..\test\core;..\test\system;..\test\libraries\inc;..\test\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ../test/src/: test.c
    ../test/src/source/: log.c message_pool.c time.c usart.c
  group core
    ../test/core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_gd32f30x_xd.s
  group system
    ../test/system/: gd32f30x.h gd32f30x_libopt.h system_gd32f30x.c system_gd32f30x.h
  group libraries
    ../test/libraries/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
